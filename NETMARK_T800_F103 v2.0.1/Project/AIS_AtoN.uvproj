# Keil uVision project AIS_AtoN.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: F103 +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER, STM32F10X_MD
  c include: ..\CMSIS;..\FWlib\inc;..\Source
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Source Group 1
    ./: startup_stm32f10x_md.s
  group Source
    ../Source/: main.c config.c msg_slot.c timer.c stm32f10x_it.c gps.c gps_algorithm.c mkmsg.c usart1.c usart2.c flashwr.c adc.c led.c power.c cmdfunc.c stm32f10x_conf.h rtc.c test.c TrajectoryPrediction.c IWDG.c usart3.c si4463.c spi.c delay.c
  group FWLIB
    ../FWlib/src/: misc.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_dma.c stm32f10x_adc.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group DOCUMENT
    ../Source/: README.txt
